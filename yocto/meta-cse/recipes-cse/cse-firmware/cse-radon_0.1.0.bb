CSE_BOARD = "radon"
SRC_URI[bin.sha256sum] = "e175f3c5aa751f1e54af1d9ac8f8cfda7ca2a748f05f4bc6e8c4bf8c9e86d307"
require cse-firmware.inc
