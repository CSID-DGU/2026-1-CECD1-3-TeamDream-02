CSE_BOARD = "servo"
require cse-image.inc
